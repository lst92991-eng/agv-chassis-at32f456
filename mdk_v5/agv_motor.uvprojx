# Keil uVision project agv_motor.uvprojx, settings and files
target agv_motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456RCT7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: agv_motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F456RCT7,USE_STDPERIPH_DRIVER,AT_START_F456_V1,USE_FREERTOS,USE_I2C_2V8
  c include: ..\src\app;..\src\services;..\src\drivers;..\src\config;..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\at32f45x_board;..\third_party\bosch_bmi270;..\third_party\freertos\include;..\third_party\freertos\portable\rvds\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  group app
    ../src/app/: main.c app_freertos.c chassis_app.c
  group services
    ../src/services/: chassis_protocol.c drive_control.c odometry.c safety.c
  group drivers
    ../src/drivers/: at32f45x_clock.c at32f45x_int.c adc_dma.c board_port.c bumper.c canfd_driver.c imu_bmi270.c motor_driver.c motor_encoder.c
  group config
    ../src/config/: board_config.h
  group bsp
    ../at32f45x_board/: at32f45x_board.c
  group freertos
    ../third_party/freertos/: tasks.c list.c queue.c
    ../third_party/freertos/portable/rvds/ARM_CM4F/: port.c
  group third_party
    ../third_party/bosch_bmi270/: bmi2.c bmi270.c
  group firmware
    ../libraries/drivers/src/: at32f45x_adc.c at32f45x_can.c at32f45x_dma.c at32f45x_wdt.c at32f45x_crm.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_pwc.c at32f45x_scfg.c at32f45x_spi.c at32f45x_tmr.c at32f45x_usart.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group readme
    ../: README.md
